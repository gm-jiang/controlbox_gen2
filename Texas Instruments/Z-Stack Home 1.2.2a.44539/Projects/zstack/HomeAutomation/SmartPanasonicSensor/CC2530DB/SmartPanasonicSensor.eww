<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SmartPanasonicSensor.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SmartPanasonicSensor</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SmartPanasonicSensor</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SmartPanasonicSensor</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


