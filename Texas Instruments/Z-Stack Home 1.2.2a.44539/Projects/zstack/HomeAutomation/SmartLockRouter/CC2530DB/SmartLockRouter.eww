<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SmartLockRouter.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SmartLockRouter</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SmartLockRouter</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SmartLockRouter</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


