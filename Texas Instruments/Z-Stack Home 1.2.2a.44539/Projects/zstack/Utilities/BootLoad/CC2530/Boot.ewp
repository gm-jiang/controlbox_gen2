# IAR project Boot.ewp, settings and files
configuration CC2530 Boot Loader (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: HAL_SB_BOOT_CODE; HAL_UART=TRUE; HAL_UART_DMA=0; HAL_UART_ISR=1; HAL_UART_ISR_RX_MAX=254
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source; source; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\_COMMON\CC2530; ..\..\..\..\..\Components\hal\target\CC2530EB
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "..\..\..\Tools\CC2530DB\oad.exe" "CC2530BL\Exe\boot.sim" "CC2530BL\Exe\boot.bin"
  XLINK.XclFile: sb-boot.xcl
  group App
    source/: sb_main.c sb_main.h ymodem.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_defs.h hal_flash.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_flash.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_dma.h hal_mcu.h hal_types.h
  group Tools
    source/: interrupt_stubs.s51
    ../../../Tools/CC2530DB/: sb-boot.xcl
