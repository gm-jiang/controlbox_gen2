# IAR project znp.ewp, settings and files
configuration Coordinator - Pro Secure Link Key Join (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; FLASH_ROM_BUILD; USE_ICALL; HEAPMGR_SIZE=6500; FEATURE_MAC_SECURITY; FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; ICALL_HOOK_ABORT_FUNC=halAssertHandler; CC26XX; xdc_runtime_Log_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; MODULE_CC26XX_7X7; xMODULE_CC26XX_5X5; xMODULE_CC26XX_4X4; ZDO_API_ADVANCED; HAL_ASSERT_SPIN; NEAR_FUNC=; DATA=; FEATURE_SYSTEM_STATS; ZDNWKMGR_MIN_TRANSMISSIONS=0; SECURE=1; TC_LINKKEY_JOIN; DSECMGR_TC_DEVICE_MAX=16; HOLD_AUTO_START; ROM_SBL; FEATURE_NVEXID; NPI; NPI_SREQRSP; NPI_USE_UART; NPI_UART_BR=115200
  ICCARM.CCDiagSuppress: pa050
  ICCARM.IExtraOptions: -f znp.cfg; -f ..\..\Tools\CC26xx\znp_f8wConfig.cfg; -f ..\..\Tools\CC26xx\f8wCoord.cfg; -f configPkg/compiler.opt.defs; --aeabi
  ICCARM.PreInclude: ../../../tools/CC26xx_Tracer/dbg.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; StackTask; AppTask; ../../../../Projects/zstack/common/CC26xx/SmartRF06; ../../../../Components/npi; ../../../../Components/mt; ../../../../Components/mt/icall; ../../../../Components/stack/icall; ../../../../Components/stack/icall/client; ../../../../Components/applib/heap; ../../../../Components/hal/include; ../../../../Components/hal/target/_common/cc26xx; ../../../../Components/hal/target/CC2650/rom; ../../../../Components/hal/target/CC2650TIRTOS; ../../../../Components/osal/include; ../../../../Components/services/sdata; ../../../../Components/services/saddr; ../../../../Components/services/nv; ../../../../Components/services/nv/cc26xx; ../../../../Components/services/aes; ../../../../Components/icall/include; ../../../../Components/mac/include; ../../../../Components/mac/include/cc26xx; ../../../../Components/mac/high_level; ../../../../Components/mac/low_level/cc26xx; ../../../../Components/mac/low_level/cc26xx/ROM_Support; ../../../../Components/mac/low_level/cc26xx/CM0_Patch; ../../../../Components/stack/icall; ../../../../Components/stack/zdo; ../../../../Components/stack/af; ../../../../Components/stack/nwk; ../../../../Components/stack/sec; ../../../../Components/stack/sys; ../../../../Components/stack/sapi; ../../../../Components/zmac; ../../../../Components/zmac/f8w; ../../../../Components/mac/include; ../../../../Projects/zstack/ZNP/Source; ../../common/CC26xx; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bin\znp_coordinator_pro_secure_linkkeyjoin.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: znp_coordinator_pro_secure_linkkeyjoin.out
  ILINK.IlinkConfigDefines: CC2650=1; USE_SYSBIOS_IN_ROM=1; FLASH_ROM_BUILD=1
  ILINK.IlinkIcfFile: cc26xx_app_stack_combined.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd; --keep __vector_table
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib; ..\..\Libraries\CC26xx\bin\Router.a; ..\..\..\..\Projects\common\TIMAC_ROM_Release\03282014\timac_rom_PATCH.symbols
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Coordinator - Pro Secure (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; FLASH_ROM_BUILD; USE_ICALL; HEAPMGR_SIZE=6500; FEATURE_MAC_SECURITY; FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; ICALL_HOOK_ABORT_FUNC=halAssertHandler; CC26XX; xdc_runtime_Log_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; MODULE_CC26XX_7X7; xMODULE_CC26XX_5X5; xMODULE_CC26XX_4X4; ZDO_API_ADVANCED; HAL_ASSERT_SPIN; NEAR_FUNC=; DATA=; FEATURE_SYSTEM_STATS; ZDNWKMGR_MIN_TRANSMISSIONS=0; SECURE=1; xTC_LINKKEY_JOIN; DSECMGR_TC_DEVICE_MAX=16; HOLD_AUTO_START; ROM_SBL; FEATURE_NVEXID; NPI; NPI_SREQRSP; NPI_USE_UART; NPI_UART_BR=115200
  OBJCOPY.OOCOutputFile: bin\znp_coordinator_pro_secure.hex
  ILINK.IlinkOutputFile: znp_coordinator_pro_secure.out
configuration Coordinator - Pro (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; FLASH_ROM_BUILD; USE_ICALL; HEAPMGR_SIZE=6500; FEATURE_MAC_SECURITY; FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; ICALL_HOOK_ABORT_FUNC=halAssertHandler; CC26XX; xdc_runtime_Log_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; MODULE_CC26XX_7X7; xMODULE_CC26XX_5X5; xMODULE_CC26XX_4X4; ZDO_API_ADVANCED; HAL_ASSERT_SPIN; NEAR_FUNC=; DATA=; FEATURE_SYSTEM_STATS; ZDNWKMGR_MIN_TRANSMISSIONS=0; SECURE=0; xTC_LINKKEY_JOIN; DSECMGR_TC_DEVICE_MAX=16; HOLD_AUTO_START; ROM_SBL; FEATURE_NVEXID; NPI; NPI_SREQRSP; NPI_USE_UART; NPI_UART_BR=115200
  OBJCOPY.OOCOutputFile: bin\znp_coordinator_pro.hex
  ILINK.IlinkOutputFile: znp_coordinator_pro.out
configuration Router - Pro Secure Link Key Join (ARM, debug)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f znp.cfg; -f ..\..\Tools\CC26xx\znp_f8wConfig.cfg; -f ..\..\Tools\CC26xx\f8wRouter.cfg; -f configPkg/compiler.opt.defs; --aeabi
  OBJCOPY.OOCOutputFile: bin\znp_router_pro_secure_linkkeyjoin.hex
  ILINK.IlinkOutputFile: znp_router_pro_secure_linkkeyjoin.out
configuration Router - Pro Secure (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.IExtraOptions: as above
  OBJCOPY.OOCOutputFile: bin\znp_router_pro_secure.hex
  ILINK.IlinkOutputFile: znp_router_pro_secure.out
configuration Router - Pro (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.IExtraOptions: as above
  OBJCOPY.OOCOutputFile: bin\znp_router_pro.hex
  ILINK.IlinkOutputFile: znp_router_pro.out
configuration End Device - Pro Secure Link Key Join (ARM, debug)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f znp.cfg; -f ..\..\Tools\CC26xx\znp_f8wConfig.cfg; -f ..\..\Tools\CC26xx\f8wEndev.cfg; -f configPkg/compiler.opt.defs; --aeabi
  OBJCOPY.OOCOutputFile: bin\znp_enddev_pro_secure_linkkeyjoin.hex
  ILINK.IlinkOutputFile: znp_enddev_pro_secure_linkkeyjoin.out
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib; ..\..\Libraries\CC26xx\bin\EndDevice.a; ..\..\..\..\Projects\common\TIMAC_ROM_Release\03282014\timac_rom_PATCH.symbols
configuration End Device - Pro Secure (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.IExtraOptions: as above
  OBJCOPY.OOCOutputFile: bin\znp_enddev_pro_secure.hex
  ILINK.IlinkOutputFile: znp_enddev_pro_secure.out
  ILINK.IlinkAdditionalLibs: as above
configuration End Device - Pro (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.IExtraOptions: as above
  OBJCOPY.OOCOutputFile: bin\znp_enddev_pro.hex
  ILINK.IlinkOutputFile: znp_enddev_pro.out
  ILINK.IlinkAdditionalLibs: as above
  group Application/Application Thread
    AppTask/: znpapp_task.c znpapp_task.h
  group Application/NPI Thread
    ../../../../Components/npi/inc/: npi_config.h npi_data.h npi_frame.h npi_rxbuf.h npi_task.h npi_tl.h npi_tl_uart.h
    ../../../../Components/npi/: npi_frame_mt.c npi_rxbuf.c npi_task.c npi_tl.c npi_tl_uart.c
  group Application/Stack Thread
    ../../../../Components/npi/inc/: npi_client.h
    ../../../../Components/npi/: npi_client_mt.c
    ./: OnBoard.c OnBoard.h osaltasks.c
    StackTask/: stack_task.c stack_task.h znp_app.c znp_app.h
    ../../../../Components/stack/icall/: zstackconfig.h
  group CM0_Patch
    ../../../../Components/mac/low_level/cc26xx/CM0_Patch/: apply_patch.h apply_zigbee_mce_patch.h apply_zigbee_rfe_patch.h rfcore_15_4_patch.h
  group DBG_TRACE
    ../../../tools/CC26xx_Tracer/: dbg.c
  group Drivers
    ../../../../../../ti/tirtos_simplelink_2_10_00_18_eng/packages/ti/drivers/: AES.h UART.h
  group HAL/Target/CC2650/_common
    ../../../../Components/hal/target/_common/cc26xx/: mb_PATCH.c pwrmon.c pwrmon.h
  group HAL/Target/CC2650/Config
    ../../../../Components/hal/target/CC2650TIRTOS/: hal_board_cfg.h hal_mac_cfg.h
  group HAL/Target/CC2650/Drivers
    ../../../../Components/hal/common/: hal_assert.c
    ../../../../Components/hal/target/CC2650TIRTOS/: hal_flash_wrapper.c hal_rtc_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group HAL/Target/CC2650/Security
    ../../../../Components/hal/target/CC2650TIRTOS/: hal_aes.c hal_aes.h hal_ccm.c hal_ccm.h
  group ICall
    ../../../../Components/icall/ports/tirtos/: CryptoBoard.c ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../Components/icall/include/: CryptoBoard.h ICall.h ICallCC26xxDefs.h
    ../../../../Components/applib/heap/: heapmgr.h
    ./: ICallAddrs.h
  group MAC/High_Level
    ../../../../Components/mac/high_level/: mac_cfg.c mac_coord_PATCH.c
  group MAC/Include
    ../../../../Components/mac/include/: mac_api.h
  group MAC/Low_Level/cc26xx
    ../../../../Components/mac/low_level/cc26xx/: mac.c mac.h mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_csma.c mac_csma.h mac_isr.c mac_isr.h mac_low_level.c mac_low_level.h mac_mcu.c mac_mcu.h mac_radio.c mac_radio.h mac_radio_defs.h mac_radio_tx.c mac_radio_tx.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MT
    ../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../Components/osal/include/: comdef.h OSAL.h osal_bufmgr.h OSAL_Clock.h OSAL_Memory.h OSAL_PwrMgr.h osal_snv.h osal_task.h OSAL_Timers.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c OSAL_Clock.c OSAL_MemoryICall.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc26xx/: osal_nv.c
  group Profile
    ../../../../Components/stack/af/: AF.c
    ../../../../Components/stack/sapi/: sapi.c sapi.h
  group Security
    ../../../../Components/stack/sec/: ssp.c ssp.h ssp_hash.c ssp_hash.h
  group Services/aes
    ../../../../Components/services/aes/: zaesccm_api.h zaesccm_cc2650.c
  group Services/nv
    ../../../../Components/services/nv/: nvintf.h
    ../../../../Components/services/nv/cc26xx/: nvoctp.c nvoctp.h
  group Startup
    ../../common/CC26xx/SmartRF06/: Board.c Board.h ccfg.c
    ../../../../Components/mac/low_level/cc26xx/ROM_Support/: CommonROM_Init.c ROM_Init.c
    ./: ICall_startup.c main.c
  group Tools
    ./: app.cfg cc26xx_app_stack_combined.icf znp.cfg
    ../../Tools/CC26xx/: f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg znp_f8wConfig.cfg
  group ZDO
    ../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../Components/zmac/f8w/: zmac.c zmac_cb.c
