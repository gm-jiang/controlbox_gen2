<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleTemperatureSensor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\Core\Thread\CC26xx\ZStackCore.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>SampleTemperatureSensor</project>
        <configuration>SmartRF06</configuration>
      </member>
      <member>
        <project>SampleTemperatureSensor</project>
        <configuration>SensorTag</configuration>
      </member>
      <member>
        <project>ZStackCore</project>
        <configuration>EndDevice</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


